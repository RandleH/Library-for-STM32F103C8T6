# IAR project Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: App; Bsp; Libraries\CMSIS\DeviceSupport; Libraries\CMSIS\DeviceSupport\startup; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\Driver\inc; Libraries\Driver\src; Libraries\Utility\inc; Libraries\Utility\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: ExecutableFile.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group App
    App/: main.cpp stm32f10x_conf.h stm32f10x_it.h
  group Bsp/inc
    Bsp/: encoder.h oled.h
  group Bsp/src
    Bsp/: encoder.cpp oled.cpp
  group CMSIS
    Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Driver/inc
    Libraries/Driver/inc/: adc.h buffer.h common.h delay.h gpio.h i2c.h interrupt.h port.h spi.h system.h
  group Driver/src
    Libraries/Driver/src/: adc.cpp buffer.cpp common.cpp delay.cpp gpio.cpp i2c.cpp interrupt.cpp port.cpp spi.cpp system.cpp
  group Startup Code
    Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Utility/inc
    Libraries/Utility/inc/: num.h
  group Utility/src
    Libraries/Utility/src/: num.cpp
